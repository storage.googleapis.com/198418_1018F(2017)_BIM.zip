Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-09-13T15:34:12
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Sep 13 15:34:12 2018 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{12877CA1-E332-4305-BC59-D8F92EE63544}\ifc * Database version: 5507 * Database creation date: Thu Sep 13 15:34:11 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Sep 13 15:34:12 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Sep 13 15:34:12 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 1018F Bidet faucet, 1018F(2017):1018F Bidet faucet:327495
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - InletConnectionSize: 10 mm; NominalDepth: 146 mm; NominalHeight: 147 mm; NominalWidth: 50 mm; Projection: 106 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 1018F(2017); ConvergoRefNr: 0087-1806-0009-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 11/09/2018
Type - Green Building Properties(Type) - EAN Number: 6414150078705; Noise Class: I (ISO 3822); NRF Number: 4201448; RSK Number: 8262582; VVS Number: 705273604
Type - Identity Data(Type) - Class: Single lever; Group: Bidet faucets; Manufacturer: Oras; Market: INT;EST;LVA;LTU;NOR;POL;RUS;SWE;UKR;DNK; Model: 1018F Bidet faucet; Name_en: 1018F Bidet faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 1018F; Product Datasheet: https://www.oras.com/datasheet/1018F/en; Product Family: Oras Safira; Product URL: https://www.oras.com/en/products/oras-safira/product/1018F/; Type Name: 1018F Bidet faucet
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Aerator: Swivel aerator; Extensions: Popup waste; Flow: Limitation option for maximum flowrate; Flow Rate At 300kPa: 0.00600349 m3/s; Installation and Maintenance: https://www.oras.com/fileadmin/resources/72397_PDM_943237_1_(943237-03-17).pdf; Installation Type: Deck mounted; Max. Hot Water Supply: 80 kg/K/s3; Mounting Holes: 1 mounting hole; Pipes: Flexible inlet pipes; Pressure Loss With Flow 01ls: 100000 Pa; Spare Parts: https://www.oras.com/en/products/oras-safira/spareparts/SP1018F/; Spout Type: FixedSpout
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Bathroom; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 1018F(2017); Features: Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 1018F; Name: 1018F Bidet faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 50x150x150 mm; SustainabilityPerformance: n/a; WarrantyDescription: https://www.oras.com/en/products/guarantee/; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 1018F; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 1018F Bidet faucet
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0372115 m2; Volume: 0.00107781 m3
Identity Data - Mark: 8
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 1018F(2017): 1018F Bidet faucet; Family and Type: 1018F(2017): 1018F Bidet faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 1018F(2017): 1018F Bidet faucet; Type Id: 1018F(2017): 1018F Bidet faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
